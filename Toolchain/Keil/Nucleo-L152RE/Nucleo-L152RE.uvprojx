# Keil uVision project Nucleo-L152RE.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L152RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Nucleo-L152RE +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin --m32 --output=$L@L.srec !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG_TARGET
  c include: ..\..\..\Src\Devices\CMSIS\Include;..\..\..\Src\Devices\ST\STM32L1xx\Include;..\..\..\Src\Devices\ST\STM32L1xx_HAL_Driver\Inc;..\..\..\Src\Devices\ST;..\..\..\Src\Boards\Nucleo-L152RE;..\..\..\Src
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  group STM32_HAL
    ../../../Src/Devices/ST/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_comp.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_cryp.c stm32l1xx_hal_cryp_ex.c stm32l1xx_hal_dac.c stm32l1xx_hal_dac_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_exti.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_i2s.c stm32l1xx_hal_irda.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_lcd.c stm32l1xx_hal_nor.c stm32l1xx_hal_opamp.c stm32l1xx_hal_opamp_ex.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_sd.c stm32l1xx_hal_smartcard.c stm32l1xx_hal_spi.c stm32l1xx_hal_sram.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c stm32l1xx_hal_wwdg.c
  group Device
    ../../../Src/Devices/ST/STM32L1xx/Source/: system_stm32l1xx.c
    ../../../Src/Devices/ST/STM32L1xx/Source/arm/: startup_stm32l152xe.s
    ../../../Src/Devices/ST/: GPIO_Drv.c Reset_Drv.c SysTick_Drv.c Timebase_Drv.c
  group Source
    ../../../Src/: main.c LEDMgr.c Lunar_InitMgr.c Lunar_Main.c Lunar_MathLib.c Lunar_Scheduler.c Lunar_SoftTimerLib.c
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L152RETx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: as above
  output: Nucleo-L152RE +hex
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RELEASE_TARGET
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
