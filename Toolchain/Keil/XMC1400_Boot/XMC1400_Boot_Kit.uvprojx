# Keil uVision project XMC1400_Boot_Kit.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: XMC1404-Q064x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.11.0
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x32000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: XMC1400_Boot_Kit +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin --m32 --output=$L@L.srec !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG_TARGET
  c include: ..\..\..\Src\Devices\CMSIS\Include;..\..\..\Src\Devices\Infineon\XMC\XMC1400_series\Include;..\..\..\Src\Devices\Infineon\XMC\XMClib\inc;..\..\..\Src\Devices\Infineon\XMC;..\..\..\Src\Boards\XMC1400_Boot_Kit;..\..\..\Src
  asm include: ..\..\..\Src\Devices\CMSIS\Include;..\..\..\Src\Devices\Infineon\XMC1400_series\Include;..\..\..\Src\Devices\Infineon\XMClib\inc;..\..\..\Src\Boards\XMC1400_Boot_Kit;..\..\..\Src
  memory RVCT4: ROM 0x10003000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  scatter file: ..\..\..\Src\Devices\Infineon\XMC\XMC1400_series\Source\ARM\XMC1400x0200_ac5.sct
  group XMCLib
    ../../../Src/Devices/Infineon/XMC/XMClib/src/: xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dma.c xmc_eru.c xmc_gpio.c xmc_hrpwm.c xmc_math.c xmc_rtc.c xmc_spi.c xmc_uart.c xmc_usic.c xmc_vadc.c xmc_wdt.c xmc1_eru.c xmc1_flash.c xmc1_gpio.c xmc1_rtc.c xmc1_scu.c
  group Device
    ../../../Src/Devices/Infineon/XMC/XMC1400_series/Source/: system_XMC1400.c
    ../../../Src/Devices/Infineon/XMC/XMC1400_series/Source/ARM/: startup_XMC1400.s
    ../../../Src/Devices/Infineon/XMC/: GPIO_Drv.c Reset_Drv.c SysTick_Drv.c Timebase_Drv.c
  group Source
    ../../../Src/: main.c LEDMgr.c Lunar_InitMgr.c Lunar_MathLib.c Lunar_Scheduler.c Lunar_SoftTimerLib.c Lunar_Main.c
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: XMC1404-Q064x0200 Infineon
  pack: Infineon.XMC1000_DFP.2.11.0
  cpu: as above
  output: XMC1400_Boot_Kit +hex
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RELEASE_TARGET
  c include: as above
  asm include: ..\..\..\Src\Devices\CMSIS\Include;..\..\..\Src\Devices\Infineon\XMC\XMC1400_series\Include;..\..\..\Src\Devices\Infineon\XMC\XMClib\inc;..\..\..\Src\Boards\XMC1400_Boot_Kit;..\..\..\Src
  memory RVCT4: ROM 0x10001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  scatter file: as above
