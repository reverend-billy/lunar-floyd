# Keil uVision project XMC4800_AWS.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: XMC4800-F100x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: IRAM(0x20000000,0x3FFC0) IRAM2(0x1FFE8000,0x18000) IROM(0x08000000,0x200000) IROM2(0x0C000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XMC4800_AWS +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe --bin --m32 --output=$L@L.srec !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG_TARGET
  c include: ..\..\..\Src\Devices\CMSIS\Include;..\..\..\Src\Devices\Infineon\XMC\XMC4800_series\Include;..\..\..\Src\Devices\Infineon\XMC\XMClib\inc;..\..\..\Src\Devices\Infineon\XMC;..\..\..\Src\Boards\XMC4800_AWS;..\..\..\Src
  asm include: ..\..\..\Src\Devices\CMSIS\Include;..\..\..\Src\Devices\Infineon\XMC\XMC4800_series\Include;..\..\..\Src\Devices\Infineon\XMC\XMClib\inc;..\..\..\Src\Boards\XMC4800_AWS;..\..\..\Src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  scatter file: ..\..\..\Src\Devices\Infineon\XMC\XMC4800_series\Source\ARM\XMC4800x2048_ac5.sct
  group XMCLib
    ../../../Src/Devices/Infineon/XMC/XMClib/src/: xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dma.c xmc_eru.c xmc_gpio.c xmc_hrpwm.c xmc_math.c xmc_rtc.c xmc_spi.c xmc_uart.c xmc_usic.c xmc_vadc.c xmc_wdt.c xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c
  group Device
    ../../../Src/Devices/Infineon/XMC/XMC4800_series/Source/: system_XMC4800.c
    ../../../Src/Devices/Infineon/XMC/XMC4800_series/Source/ARM/: startup_XMC4800.s
    ../../../Src/Devices/Infineon/XMC/: CAN_Drv.c GPIO_Drv.c Reset_Drv.c RTC_Drv.c SysTick_Drv.c Timebase_Drv.c UART_Drv.c
  group Board
    ../../../Src/Boards/XMC4800_AWS/: ReportMgr.c Control.c
  group Source
    ../../../Src/: main.c LEDMgr.c Lunar_CircularBufferLib.c Lunar_ErrorMgr.c Lunar_EventMgr.c Lunar_InitMgr.c Lunar_Main.c Lunar_MathLib.c Lunar_MessageRouter.c Lunar_Scheduler.c Lunar_Serial.c Lunar_SoftTimerLib.c
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: XMC4800-F100x2048 Infineon
  pack: Infineon.XMC4000_DFP.2.13.0
  cpu: as above
  output: XMC4800_AWS +hex
  AfterMake: as above
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RELEASE_TARGET
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x3ffc0
  memory RVCT10: RAM 0x1ffe8000 size 0x18000
  scatter file: as above
